# IAR project H2H.ewp, settings and files
configuration H2H (ARM, debug)
  General.OGChipSelectEditMenu: STM32L162xD ST STM32L162xD
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32L162xD
  ICCARM.CCIncludePath2: ../Inc; ../../../Devices/STM32L1/STM32L1xx_HAL_Driver/Inc; ../../../Devices/STM32L1/STM32L1xx_HAL_Driver/Inc/Legacy; ../../../Devices/STM32L1/CMSIS/Include; ../../../Devices/STM32L1/CMSIS/Device/ST/STM32L1xx/Include; ../../../Devices/STM32L1/STM32L1xx_StdPeriph_Lib/STM32L1xx_StdPeriph_Driver/inc; ../../../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM3; ../../../Middlewares/Third_Party/FreeRTOS/Source/include; ../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS; ../../../Bluetopia/btpskrnl; ../../../Bluetopia/btpsvend; ../../../Bluetopia/btvs; ../../../Bluetopia/hcitrans.dma; ../../../Bluetopia/include; ../../../GenericRecorderLibSrc/Include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\Inc
  OBJCOPY.OOCOutputFile: H2H.srec
  ILINK.IlinkOutputFile: H2H.out
  ILINK.IlinkIcfFile: stm32l162xd_flash.icf
  ILINK.IlinkAdditionalLibs: ../../../Bluetopia/lib/ewarm/Bluetopia_16_M3.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ../../../Devices/STM32L1/CMSIS/Device/ST/STM32L1xx/Source/Templates/iar/: startup_stm32l162xd.s
  group Application/User
    ../Src/: freertos.c main.c stm32l1xx_hal_msp.c stm32l1xx_it.c
  group Application/User/autentification
    ../Src/: authentication.c
  group Application/User/dsp
    ../Src/: dsp.c
  group Application/User/fsm
    ../Src/: fsm_client.c state.c
  group Application/User/fsm/states
    ../Src/: state_goodbye.c state_welcome.c
  group Application/User/fsm/states/running
    ../Src/: state_running.c
  group Application/User/fsm/states/running/h2h
    ../Src/: state_h2h_auth.c state_h2h_connected.c state_h2h_keygen.c state_h2h_wait.c state_h2h_waitkey.c
  group Application/User/hardware/afe
    ../Src/: afe.c
  group Application/User/hardware/afe/hal
    ../Inc/: afe_constants.h
    ../Src/: afe_hal.c
  group Application/User/hardware/bluetooth
    ../Src/: bluetooth_internal.c
    ../Inc/: bt_const_and_struct.h
  group Application/User/hardware/bluetooth/Bluetopia
    ../../../Bluetopia/btpskrnl/: BTPSKRNL.c
    ../../../Bluetopia/btpsvend/: BTPSVEND.c
    ../../../Bluetopia/btvs/: BTVS.c
    ../../../Bluetopia/hcitrans.dma/: HCITRANS.c
  group Application/User/hardware/buzzer
    ../Src/: buzzer.c
  group Application/User/hardware/gauge
    ../Src/: gauge.c
  group Application/User/hardware/gauge/hal
    ../Inc/: gauge_constants.h
    ../Src/: gauge_hal.c
  group Application/User/modules
    ../Src/: dma.c fsmc.c gpio.c i2c.c rtc.c spi.c tim.c usart.c
  group Application/User/tasks
    ../Src/: tasks_bt.c tasks_ecg.c tasks_fsm.c tasks_input.c tasks_periph.c
  group Application/User/tasks/res
    ../Inc/: leads.h
  group Drivers/CMSIS
    ../../../Devices/STM32L1/CMSIS/Device/ST/STM32L1xx/Source/Templates/: system_stm32l1xx.c
  group Drivers/STM32L1xx_HAL_Driver
    ../../../Devices/STM32L1/STM32L1xx_HAL_Driver/Src/: stm32l1xx_hal.c stm32l1xx_hal_cortex.c stm32l1xx_hal_dma.c stm32l1xx_hal_flash.c stm32l1xx_hal_flash_ex.c stm32l1xx_hal_flash_ramfunc.c stm32l1xx_hal_gpio.c stm32l1xx_hal_i2c.c stm32l1xx_hal_pwr.c stm32l1xx_hal_pwr_ex.c stm32l1xx_hal_rcc.c stm32l1xx_hal_rcc_ex.c stm32l1xx_hal_rtc.c stm32l1xx_hal_rtc_ex.c stm32l1xx_hal_spi.c stm32l1xx_hal_spi_ex.c stm32l1xx_hal_sram.c stm32l1xx_hal_tim.c stm32l1xx_hal_tim_ex.c stm32l1xx_hal_uart.c stm32l1xx_ll_fsmc.c
  group Middlewares/FreeRTOS
    ../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../../../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../../../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM3/: port.c portasm.s
  group Tracer
    ../../../GenericRecorderLibSrc/: trcBase.c trcHardwarePort.c trcKernel.c trcKernelPortFreeRTOS.c trcUser.c
