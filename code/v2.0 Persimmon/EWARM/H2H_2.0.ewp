# IAR project H2H_2.0.ewp, settings and files
configuration H2H_2.0 (ARM, debug)
  General.OGChipSelectEditMenu: STM32L162xD ST STM32L162xD
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32L162xD
  ICCARM.CCIncludePath2: ../Inc; ../Drivers/STM32L1xx_HAL_Driver/Inc; ../Drivers/STM32L1xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Include; ../Drivers/CMSIS/Device/ST/STM32L1xx/Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkOutputFile: H2H_2.0.out
  ILINK.IlinkIcfFile: stm32l162xd_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ../Drivers/CMSIS/Device/ST/STM32L1xx/Source/Templates/iar/: startup_stm32l162xd.s startup_stm32l162xd.s
  group Application/User
    ../Src/: fsmc.c gpio.c i2c.c main.c spi.c stm32l1xx_hal_msp.c stm32l1xx_it.c tim.c usart.c i2c.c usart.c stm32l1xx_hal_msp.c gpio.c fsmc.c main.c tim.c stm32l1xx_it.c spi.c
  group Drivers/CMSIS
    ../Drivers/CMSIS/Device/ST/STM32L1xx/Source/Templates/: system_stm32l1xx.c system_stm32l1xx.c
  group Drivers/STM32L1xx_HAL_Driver
    ../Drivers/STM32L1xx_HAL_Driver/Src/: stm32l1xx_hal.c stm32l1xx_hal_cortex.c stm32l1xx_hal_dma.c stm32l1xx_hal_flash.c stm32l1xx_hal_flash_ex.c stm32l1xx_hal_flash_ramfunc.c stm32l1xx_hal_gpio.c stm32l1xx_hal_i2c.c stm32l1xx_hal_pwr.c stm32l1xx_hal_pwr_ex.c stm32l1xx_hal_rcc.c stm32l1xx_hal_rcc_ex.c stm32l1xx_hal_rtc.c stm32l1xx_hal_rtc_ex.c stm32l1xx_hal_spi.c stm32l1xx_hal_spi_ex.c stm32l1xx_hal_sram.c stm32l1xx_hal_tim.c stm32l1xx_hal_tim_ex.c stm32l1xx_hal_uart.c stm32l1xx_ll_fsmc.c stm32l1xx_hal_tim.c stm32l1xx_hal_cortex.c stm32l1xx_hal_tim_ex.c stm32l1xx_hal_rtc.c stm32l1xx_hal_pwr.c stm32l1xx_hal_spi.c stm32l1xx_hal.c stm32l1xx_hal_flash_ramfunc.c stm32l1xx_hal_flash.c stm32l1xx_hal_spi_ex.c stm32l1xx_hal_gpio.c stm32l1xx_hal_rcc_ex.c stm32l1xx_hal_pwr_ex.c stm32l1xx_ll_fsmc.c stm32l1xx_hal_flash_ex.c stm32l1xx_hal_i2c.c stm32l1xx_hal_dma.c stm32l1xx_hal_sram.c stm32l1xx_hal_uart.c stm32l1xx_hal_rtc_ex.c stm32l1xx_hal_rcc.c
