# IAR project H2H_2.0.ewp, settings and files
configuration H2H_2.0 (ARM, debug)
  General.OGChipSelectEditMenu: STM32L162xD ST STM32L162xD
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32L162xD
  ICCARM.CCIncludePath2: ../Inc; ../../../Devices/STM32L1/STM32L1xx_HAL_Driver/Inc; ../../../Devices/STM32L1/STM32L1xx_HAL_Driver/Inc/Legacy; ../../../Devices/STM32L1/CMSIS/Include; ../../../Devices/STM32L1/CMSIS/Device/ST/STM32L1xx/Include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: H2H_2.0.srec
  ILINK.IlinkOutputFile: H2H_2.0.out
  ILINK.IlinkIcfFile: stm32l162xd_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ../../../Devices/STM32L1/CMSIS/Device/ST/STM32L1xx/Source/Templates/iar/: startup_stm32l162xd.s
  group Application/User
    ../Src/: dma.c fsmc.c gpio.c i2c.c main.c rtc.c spi.c stm32l1xx_hal_msp.c stm32l1xx_it.c tim.c usart.c
  group Application/User/afe
    ../Src/: afe.c
    ../Inc/: afe_constants.h
  group Application/User/gauge
    ../Src/: gauge.c
    ../Inc/: gauge_constants.h
  group Application/User/screen/lcd
    ../Src/: lcd.c
    ../Inc/: lcd_constants.h
  group Application/User/screen/lcd/graphic/color
    ../Src/: color.c
  group Application/User/screen/lcd/graphic/fonts
    ../Src/: myriad_pro_semibold.c
  group Application/User/screen/lcd/graphic/items
    ../Src/: area.c text_area.c
  group Application/User/screen/lcd/graphic/primitives
    ../Src/: lcd_primitives.c
  group Application/User/screen/lcd/graphic/primitives/hal
    ../Src/: lcd_hal.c
    ../Inc/: lcd_position.h
  group Application/User/screen/touch
    ../Src/: touch.c
    ../Inc/: touch_constants.h
  group Application/User/screen/touch/calibration
    ../Src/: touch_calib.c
  group Application/User/screen/touch/hal
    ../Src/: touch_hal.c
    ../Inc/: touch_position.h
  group Drivers/CMSIS
    ../../../Devices/STM32L1/CMSIS/Device/ST/STM32L1xx/Source/Templates/: system_stm32l1xx.c
  group Drivers/STM32L1xx_HAL_Driver
    ../../../Devices/STM32L1/STM32L1xx_HAL_Driver/Src/: stm32l1xx_hal.c stm32l1xx_hal_adc.c stm32l1xx_hal_adc_ex.c stm32l1xx_hal_comp.c stm32l1xx_hal_cortex.c stm32l1xx_hal_crc.c stm32l1xx_hal_cryp.c stm32l1xx_hal_cryp_ex.c stm32l1xx_hal_dac.c stm32l1xx_hal_dac_ex.c stm32l1xx_hal_dma.c stm32l1xx_hal_flash.c stm32l1xx_hal_flash_ex.c stm32l1xx_hal_flash_ramfunc.c stm32l1xx_hal_gpio.c stm32l1xx_hal_i2c.c stm32l1xx_hal_i2s.c stm32l1xx_hal_irda.c stm32l1xx_hal_iwdg.c stm32l1xx_hal_lcd.c stm32l1xx_hal_nor.c stm32l1xx_hal_opamp.c stm32l1xx_hal_opamp_ex.c stm32l1xx_hal_pcd.c stm32l1xx_hal_pcd_ex.c stm32l1xx_hal_pwr.c stm32l1xx_hal_pwr_ex.c stm32l1xx_hal_rcc.c stm32l1xx_hal_rcc_ex.c stm32l1xx_hal_rtc.c stm32l1xx_hal_rtc_ex.c stm32l1xx_hal_sd.c stm32l1xx_hal_smartcard.c stm32l1xx_hal_spi.c stm32l1xx_hal_spi_ex.c stm32l1xx_hal_sram.c stm32l1xx_hal_tim.c stm32l1xx_hal_tim_ex.c stm32l1xx_hal_uart.c stm32l1xx_hal_usart.c stm32l1xx_hal_wwdg.c stm32l1xx_ll_fsmc.c stm32l1xx_ll_sdmmc.c
