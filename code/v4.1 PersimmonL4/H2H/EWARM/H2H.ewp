# IAR project H2H.ewp, settings and files
configuration H2H (ARM, debug)
  General.OGChipSelectEditMenu: STM32L486VG ST STM32L486VG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32L486xx
  ICCARM.CCIncludePath2: ../Inc; ../Drivers/STM32L4xx_HAL_Driver/Inc; ../Drivers/STM32L4xx_HAL_Driver/Inc/Legacy; ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM4F; ../Middlewares/Third_Party/FreeRTOS/Source/include; ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS; ../Drivers/CMSIS/Include; ../Drivers/CMSIS/Device/ST/STM32L4xx/Include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\Inc
  OBJCOPY.OOCOutputFile: H2H.srec
  ILINK.IlinkOutputFile: H2H.out
  ILINK.IlinkIcfFile: stm32l486xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ../Drivers/CMSIS/Device/ST/STM32L4xx/Source/Templates/iar/: startup_stm32l486xx.s
  group Application/User
    ../Src/: freertos.c main.c stm32l4xx_hal_msp.c stm32l4xx_it.c
  group Application/User/dsp
    ../Src/: dsp.c
  group Application/User/hardware/afe
    ../Src/: afe.c
  group Application/User/hardware/afe/hal
    ../Inc/: afe_constants.h
    ../Src/: afe_hal.c
  group Application/User/modules
    ../Src/: dma.c fmc.c gpio.c i2c.c rtc.c spi.c tim.c usart.c
  group Application/User/tasks
    ../Src/: tasks_ecg.c
  group Drivers/CMSIS
    ../Drivers/CMSIS/Device/ST/STM32L4xx/Source/Templates/: system_stm32l4xx.c
  group Drivers/STM32L4xx_HAL_Driver
    ../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_cortex.c stm32l4xx_hal_dma.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_gpio.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_rtc.c stm32l4xx_hal_rtc_ex.c stm32l4xx_hal_spi.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_sram.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c stm32l4xx_ll_fmc.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM4F/: port.c portasm.s
